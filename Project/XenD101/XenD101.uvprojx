# Keil uVision project XenD101.uvprojx, settings and files
target XenD101 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PY32F003x4 Puya
  pack: Puya.PY32F0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: XenD101_1_4m +hex
  BeforeMake: ..\..\Script\XenD101_Convert.bat
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,PY32_PLATFORM,XenD101,
  c include: ..\..\App\common\inc;..\..\App\algo\inc;..\..\Config;..\..\Middleware\common\inc;..\..\Middleware\common\src;..\..\Middleware\platform\py32\inc;..\..\Driver\py32f003\PY32F003_HAL_Driver\Inc;..\..\Driver\py32f003\CMSIS\Device\PY32F003\Include;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ../../App/common/src/: main.c system.c dataprocess.c cmdprocess.c config.c utilities.c
    ../../App/algo/src/: abd.c
  group Middleware/common
    ../../Middleware/common/src/: platform.c radar.c
  group Middleware/platform
    ../../Middleware/platform/py32/src/: py32_it.c py32_gpio.c py32_spi.c py32_i2c.c py32_uart.c py32_tim.c py32_pwr.c py32_iwdg.c py32_flash.c
  group Driver
    ../../Driver/py32f003/CMSIS/Device/PY32F003/Source/ARM/: startup_py32f003.s
    ../../Driver/py32f003/CMSIS/Device/PY32F003/: system_py32f003.c
    ../../Driver/py32f003/PY32F003_HAL_Driver/Src/: py32f003_hal.c py32f003_hal_cortex.c py32f003_hal_dma.c py32f003_hal_exti.c py32f003_hal_flash.c py32f003_hal_gpio.c py32f003_hal_i2c.c py32f003_hal_iwdg.c py32f003_hal_lptim.c py32f003_hal_rcc.c py32f003_hal_rcc_ex.c py32f003_hal_spi.c py32f003_hal_tim.c py32f003_hal_tim_ex.c py32f003_hal_uart.c py32f003_hal_usart.c py32f003_hal_wwdg.c py32f003_ll_rcc.c py32f003_hal_pwr.c
software components: CMSIS:CORE 5.5.0
